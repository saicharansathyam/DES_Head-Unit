# Enable IVI-Shell support in Weston
PACKAGECONFIG:append = " ivi-shell"
